# Keil uVision project LED.uvprojx, settings and files
target LED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\Utils;..\SYSTEM\TIMER;..\SYSTEM\USART3;..\HARDWARE\Buzzer;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\ADCX;..\HARDWARE\MyRTC;..\HARDWARE\DHT11;..\HARDWARE\Serial;..\HARDWARE\PWM;..\HARDWARE\Serial2;..\HARDWARE\HC-SR501
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/Buzzer/: Buzzer.c Buzzer.h
    ../HARDWARE/KEY/: Key.c Key.h
    ../HARDWARE/OLED/: OLED.c OLED.h OLED_Font.h
    ../HARDWARE/MyRTC/: MyRTC.c MyRTC.h
    ../HARDWARE/Serial/: Serial.c Serial.h
    ../HARDWARE/ADCX/: AD.c AD.h
    ../HARDWARE/PWM/: PWM.c PWM.h
    ../HARDWARE/Serial2/: Serial2.c Serial2.h
    ../HARDWARE/HC-SR501/: body_hw.c body_hw.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c
    ../CORE/STARTUP/: startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c
  group README
    ../: README.TXT
